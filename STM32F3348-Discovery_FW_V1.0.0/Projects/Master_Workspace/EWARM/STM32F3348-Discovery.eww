<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\Demonstration\EWARM\STM32F3348-Discovery_Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\ADC_Example\EWARM\ADC_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\CRC_8BitsMessage\EWARM\CRC_8BitsMessage.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\CRC_32BitsMessage\EWARM\CRC_32BitsMessage.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DMA_FLASH_RAM\EWARM\DMA_FLASH_RAM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DMA_RAM_DAC\EWARM\DMA_RAM_DAC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\EXTI_Example\EWARM\EXTI_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\FLASH_Program\EWARM\FLASH_Program.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\FLASH_Program\EWARM\FLASH_Program.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\GPIO_IOToggle\EWARM\GPIO_IOToggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\IWDG_Reset\EWARM\IWDG_Reset.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\OPAMP_PGA\EWARM\OPAMP_PGA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_CurrentConsumption\EWARM\PWR_CurrentConsumption.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_STANDBY\EWARM\PWR_STANDBY.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_STOP\EWARM\PWR_STOP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\RTC_Calendar\EWARM\RTC_Calendar.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\SysTick_Example\EWARM\SysTick_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_Combined\EWARM\TIM_Combined.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_ComplementarySignals\EWARM\TIM_ComplementarySignals.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_PWM_Input\EWARM\TIM_PWM_Input.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_TimeBase\EWARM\TIM_TimeBase.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\WWDG_Example\EWARM\WWDG_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Template\EWARM\Template.ewp</path>
  </project>
  <batchBuild/>
</workspace>


