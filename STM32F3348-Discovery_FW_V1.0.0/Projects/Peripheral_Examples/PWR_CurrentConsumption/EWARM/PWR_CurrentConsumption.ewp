# IAR project PWR_CurrentConsumption.ewp, settings and files
configuration PWR_CurrentConsumption (ARM, debug)
  General.OGChipSelectEditMenu: STM32F334x8 ST STM32F334x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F334x8
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F3348-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWR_CurrentConsumption.hex
  ILINK.IlinkOutputFile: PWR_CurrentConsumption.out
  ILINK.IlinkIcfFile: stm32f3348_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/iar/: startup_stm32f334x8.s
  group STM32F30x_StdPeriph_Driver
    ../../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group STM32F3348-Discovery
    ../../../../Utilities/STM32F3348-Discovery/: stm32f3348_discovery.c
  group User
    ../: main.c stm32f33x_lp_modes.c stm32f3xx_it.c system_stm32f30x.c
